*
Vin	Vin	0	AC	1
*
R045	Vin	2	10K
R042	2	0	10K
C031	2	0	0.47UF
C029	2	Vout	0.033UF
R040	Vout	0	100K
*
