*
Vin	1	0	AC	1
Vout	2	0
*
R1	1	2	100K
C1	2	0	0.015UF
*
