*
Vin	Vin	0	AC	1V
*
R1	0	Vout	100K
C1	Vin	Vout	0.015UF
*
