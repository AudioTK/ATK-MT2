*
Vin	Vin	0	AC	1
*
R1	Vin	2	10K
R2	2	0	10K
C1	2	0	0.047UF
C2	2	Vout	0.033UF
R3	Vout	0	100K
*
