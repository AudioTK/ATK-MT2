*
Vin	1	0	AC	1
*
R1	1	2	10K
R2	2	0	10K
C1	2	0	0.047UF
C2	2	3	0.033UF
R2	3	0	100K
*
